/********************************************************************************************************************************************
*                                                                                                                                           *
*              ---------------------------------以下是模块的修改记录区-----------------------------------------                             *
*                                                                                                                                           *
********************************************************************************************************************************************/
/**********************************************
 * 内容：
 * 日期：2025-09-08
 * 作者：YJX
 * 版本号：V1.0（初版）
 ***********************************************
 * 修改内容：
 * 修改日期：
 * 修改作者：
 * 版本号：
 ***********************************************
*/
/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下模块的说明区-----------------------------------------                                  *
*                                                                                                                                           *
********************************************************************************************************************************************/
/*	

*/
#include "DRI_RCU.h"
/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下模块的对接函数区-----------------------------------------                                  *
*                                                                                                                                           *
********************************************************************************************************************************************/


/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下是模块的变量申明和宏定义区--------------------------------                      *
*                                                                                                                                           *
********************************************************************************************************************************************/


/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下是模块的内部函数申明区------------------------------------                          *
*                                                                                                                                           *
********************************************************************************************************************************************/


/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下是模块的系统函数代码区------------------------------------                          *
*                                                                                                                                           *
********************************************************************************************************************************************/


/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下是模块的用户函数代码区------------------------------------                          *
*                                                                                                                                           *
********************************************************************************************************************************************/
/***************************************************************************
* 函 数 名: DRI_RCU_GetResetFlag
* 功能描述：获取复位类型
* 入口参数：
            无
* 出口参数：
            复位类型
* 注意事项:  
            无
* 例     如:
* 修改记录 :
*           2025-09-08 BY:YJX
***************************************************************************/
ResetFlag DRI_RCU_GetResetFlag(void)
{
     u32 u32resetFlag = RCU_RSTSCK;

     if(u32resetFlag & RCU_RSTSCK_LPRSTF)
     {
          return LP_Rst;
     }
     else if(u32resetFlag & RCU_RSTSCK_WWDGTRSTF)
     {
          return WWDGT_Rst;
     }
     else if(u32resetFlag & RCU_RSTSCK_FWDGTRSTF)
     {
          return FWDGT_Rst;
     }
     else if(u32resetFlag & RCU_RSTSCK_SWRSTF)
     {
          return SW_Rst;
     }
     else if(u32resetFlag & RCU_RSTSCK_PORRSTF)
     {
          return POR_Rst;
     }
     else if(u32resetFlag & RCU_RSTSCK_EPRSTF)
     {
          return EP_Rst;
     }        
     else
     {
          return Multiply_Rst;
     }
}

/***************************************************************************
* 函 数 名: DRI_RCU_ClearResetFlag
* 功能描述：清除所有复位类型
* 入口参数：
            无
* 出口参数：
            无
* 注意事项:  
            无
* 例     如:
* 修改记录 :
*           2025-09-08 BY:YJX
***************************************************************************/
void DRI_RCU_ClearResetFlag(void)
{
     //RCU_RSTSCK |= RCU_RSTSCK_RSTFC;
     rcu_all_reset_flag_clear();
}

/********************************************************************************************************************************************
*                                                                                                                                           *
*               ----------------------------------以下是模块的内部函数代码区------------------------------------                          *
*                                                                                                                                           *
********************************************************************************************************************************************/


