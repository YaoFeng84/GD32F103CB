# Keil uVision project GD32F103CB.uvprojx, settings and files
target GD32F103CB (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32F103CB (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\GD32F103CB_Code\CommHead;..\GD32F103CB_Code\CommHead\CMSIS;..\GD32F103CB_Code\CommHead\Peripheral;..\GD32F103CB_Code\CommHead\USB;..\..\..\MyCodeLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../GD32F103CB_Code/CommSrc/: system_gd32f10x.c
  group Perpheral
    ../GD32F103CB_Code/CommSrc/Peripheral/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group USB
    ../GD32F103CB_Code/CommSrc/USB/: usbd_core.c usbd_enum.c usbd_transc.c usbd_lld_core.c usbd_lld_int.c usbd_pwr.c
  group DRI
    ../GD32F103CB_Code/: DRI_ComDriver.c DRI_CLK.c DRI_GPIO.c DRI_Systick.c DRI_USARTn.c DRI_RCU.c DRI_Flash.c DRI_USB.c
